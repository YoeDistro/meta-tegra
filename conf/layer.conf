## conf/layer.conf
```bitbake
LAYERNAME = "meta-tegra"
LAYERSERIES_COMPAT = "garburn"
addpylib ${LAYERDIR}/lib oe4t
```
